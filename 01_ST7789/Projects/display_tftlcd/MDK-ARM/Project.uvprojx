# Keil uVision project Project.uvprojx, settings and files
target FT32F030X (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: FT32F030G8BUx FMD
  pack: FMD.FT32F0xx_DFP.1.0.4
  cpu: IRAM(0x20000000,0x00002000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: FT32F0XX +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: FT32F030,USE_STDPERIPH_DRIVER,USE_FT32F030XX_EVAL,USE_DEFAULT_TIMEOUT_CALLBACK,FT32,DEBUG,
  c include: ..\;..\..\..\Libraries\CMSIS\Device\FT\FT32F0xx\Include;..\..\..\Libraries\CMSIS\Include;..\..\..\Libraries\FT32F0xx_StdPeriph_Driver\inc;..\..\..\Libraries\FT32F0xx_CPAL_Driver\inc;..\..\..\Utilities\FT32_EVAL\Common;..\..\..\Utilities\FT32_EVAL\FT32F030xx_EVAL;..\..\..\develop_lib\ft_lib\gpio;..\..\..\develop_lib\ft_lib\systick;..\..\..\develop_lib\ft_lib\timer;..\..\..\develop_lib\ft_lib\usart;..\..\..\develop_lib\middle_api\delay;..\..\..\develop_lib\middle_api\mid_gpio;..\..\..\develop_lib\middle_api\mid_systick;..\..\..\develop_lib\middle_api\mid_timer;..\..\..\develop_lib\middle_api\trace;..\..\..\develop_lib\middle_api\queue;..\..\..\develop_lib\ft_lib;..\..\..\develop_lib\middle_api;..\..\..\develop_lib\third_lib;..\..\..\develop_lib\third_lib\app_timer;..\..\..\develop_lib\third_lib\crc32;..\..\..\develop_lib;..\..\..\develop_lib\ft_lib\i2c;..\..\..\develop_lib\ft_lib\flash;..\..\..\develop_lib\ft_lib\timer_pwm;..\..\..\develop_lib\ft_lib\exit;..\..\..\develop_lib\ft_lib\adc;..\..\..\develop_lib\middle_api\tft_8080;..\..\..\develop_lib\middle_api\mid_bk953x;..\..\..\develop_lib\middle_api\mid_flash;..\..\..\develop_lib\middle_api\adc;..\..\..\develop_lib\middle_api\ir;..\..\..\develop_lib\middle_api\pwm;..\..\..\develop_lib\hardware;..\..\..\develop_lib\hardware\bk953x;..\..\..\develop_lib\hardware\ht1621;..\..\..\develop_lib\hardware\st7789;..\..\..\develop_lib\third_lib\app_scheduler;..\app;..\..\..\develop_lib\hardware\st7789;..\..\..\develop_lib\middle_api\mid_tftlcd;..\..\..\Libraries\CMSIS\Device\Include;..\..\..\Libraries\CMSIS\Device;..\..\..\Libraries\FT32F0xx_StdPeriph_Driver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group CMSIS
    ../: system_ft32f0xx.c
    ../../../Libraries/CMSIS/Device/: startup_ft32f030x8.s
  group app
    ../: main.c ft32f0xx_it.c
    ../app/: tft_lcd_handler.c
  group StdPeriph_Driver
    ../../../Libraries/FT32F0xx_StdPeriph_Driver/src/: ft32f030x8_adc.c ft32f030x8_comp.c ft32f030x8_crc.c ft32f030x8_crs.c ft32f030x8_dac.c ft32f030x8_dbgmcu.c ft32f030x8_dma.c ft32f030x8_exti.c ft32f030x8_flash.c ft32f030x8_gpio.c ft32f030x8_i2c.c ft32f030x8_iwdg.c ft32f030x8_misc.c ft32f030x8_opa.c ft32f030x8_pwr.c ft32f030x8_rcc.c ft32f030x8_rtc.c ft32f030x8_spi.c ft32f030x8_syscfg.c ft32f030x8_tim.c ft32f030x8_usart.c ft32f030x8_wwdg.c
  group hardware
    ../../../develop_lib/hardware/st7789/: st7789.c
  group ft_lib
    ../../../develop_lib/ft_lib/gpio/: ft_gpio.c
    ../../../develop_lib/ft_lib/systick/: ft_systick.c
    ../../../develop_lib/ft_lib/timer/: ft_timer.c
    ../../../develop_lib/ft_lib/usart/: ft_usart.c retarget.c
    ../../../develop_lib/ft_lib/i2c/: ft_i2c.c
    ../../../develop_lib/ft_lib/exit/: ft_exit.c
    ../../../develop_lib/ft_lib/adc/: ft_adc.c
  group moddle_api
    ../../../develop_lib/middle_api/mid_gpio/: mid_gpio.c
    ../../../develop_lib/middle_api/trace/: trace.c
    ../../../develop_lib/middle_api/delay/: mid_delay.c
    ../../../develop_lib/middle_api/mid_systick/: mid_systick.c
    ../../../develop_lib/middle_api/adc/: mid_adc.c
    ../../../develop_lib/middle_api/mid_tftlcd/: mid_tftlcd.c
