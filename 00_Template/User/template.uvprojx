# Keil uVision project template.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F030R8Tx STMicroelectronics
  pack: Keil.STM32F0xx_DFP.2.0.0
  cpu: IRAM(0x20000000,0x00002000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: template +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: FT32F030,USE_STDPERIPH_DRIVER
  c include: ..\CMSIS;..\CMSIS\Include;..\Lib\inc;..\Startup;..\User;..\driver\LED;..\driver\ST7789;..\driver\delay
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group CMSIS
    ../CMSIS/: system_ft32f0xx.c
  group DRIVER
    ../driver/LED/: led.c
    ../driver/ST7789/: ST7789.c
    ../driver/delay/: delay.c
  group LIB
    ../Lib/src/: ft32f030x8_adc.c ft32f030x8_comp.c ft32f030x8_crc.c ft32f030x8_crs.c ft32f030x8_dac.c ft32f030x8_dbgmcu.c ft32f030x8_dma.c ft32f030x8_exti.c ft32f030x8_flash.c ft32f030x8_gpio.c ft32f030x8_i2c.c ft32f030x8_iwdg.c ft32f030x8_misc.c ft32f030x8_opa.c ft32f030x8_pwr.c ft32f030x8_rcc.c ft32f030x8_rtc.c ft32f030x8_spi.c ft32f030x8_syscfg.c ft32f030x8_tim.c ft32f030x8_usart.c ft32f030x8_wwdg.c
  group STARTUP
    ../Startup/: startup_ft32f030x8.s
  group USER
    ./: main.c ft32f0XX_it.c
